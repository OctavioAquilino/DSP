options:
  parameters:
    generate_options: qt_gui
    id: ejercicio2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '22050'
  states: {}
- name: taps
  id: variable_file_filter_taps
  parameters:
    file: /Users/nicolasrojo/DSP/ejtayi/DSP/ejercicio_2/taps_fir_martin.txt
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/nicolasrojo/DSP/ejtayi/DSP/ejercicio_2/salida_filtrada_martin.wav
    repeat: 'True'
  states: {}
- name: blocks_wavfile_source_0_0
  id: blocks_wavfile_source
  parameters:
    alias: original
    file: /Users/nicolasrojo/DSP/ejtayi/DSP/martin_m1.wav
    repeat: 'True'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: samp_rate
    color1: '"dark blue"'
    fc: '0'
    fftsize: '1024'
    label1: filtrada con taps
    label2: normalizada con python
    label3: original
    nconnections: '3'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: filtrada con taps
    label2: normalizada con python
    label3: original
    nconnections: '3'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [blocks_throttle2_0, '0', fir_filter_xxx_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_wavfile_source_0_0, '0', blocks_throttle2_0, '0']
- [blocks_wavfile_source_0_0, '0', qtgui_freq_sink_x_0, '2']
- [blocks_wavfile_source_0_0, '0', qtgui_time_sink_x_0, '2']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
