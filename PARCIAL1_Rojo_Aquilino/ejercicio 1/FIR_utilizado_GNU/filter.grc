options:
  parameters:
    generate_options: qt_gui
    id: filterDSP
    output_language: python
    title: TrabajoDSP
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: taps_0
  id: variable_file_filter_taps
  parameters:
    file: /Users/nicolasrojo/DSP/files/fir_taps_1200hz.txt
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /Users/nicolasrojo/Downloads/martin_m1.wav
    repeat: 'True'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: taps_0
    type: fff
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    name: filter
    nconnections: '2'
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [blocks_throttle2_0, '0', fir_filter_xxx_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']
- [fir_filter_xxx_0, '0', audio_sink_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
